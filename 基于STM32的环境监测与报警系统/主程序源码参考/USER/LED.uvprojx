# Keil uVision project LED.uvprojx, settings and files
target LED (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\DHT11;..\NET\cJSON;..\NET\device;..\NET\MQTT;..\NET\onenet;..\HARDWARE\BH1750;..\HARDWARE\ADC;..\SYSTEM\TIMER;..\HARDWARE\MQ2;..\HARDWARE\RELAY;..\HARDWARE\PUMP;..\HARDWARE\FS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/BH1750/: bh1750.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/MQ2/: mq2.c
    ../HARDWARE/RELAY/: relay.c
    ../HARDWARE/PUMP/: pump.c
    ../HARDWARE/FS/: fs.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/TIMER/: timer.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_tim.c
  group README
    ../: README.TXT
  group NET
    ../NET/cJSON/: cJSON.c
    ../NET/device/: esp8266.c
    ../NET/MQTT/: MqttKit.c
    ../NET/onenet/: onenet.c
